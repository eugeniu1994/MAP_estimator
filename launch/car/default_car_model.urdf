Commit message: something

File: launch/car/default_car_model.urdf (robot description, URDF)
Before this commit: robot car, 1 links, 0 joints
Links:
- link MLS: geometry visual mesh filename=package://s_mls/launch/car/model.dae scale=1.5 1.5 1.5
